# Keil uVision project H7FreeRTOS.uvprojx, settings and files
target STM32H7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H7FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --c99
  c include: ..\CMSIS;..\freeRTOS;..\freeRTOS\include;..\freeRTOS\porttable\MemMang;..\freeRTOS\porttable\RVDS;..\freeRTOS\porttable;..\FWlib\Inc;..\FWlib\Src;..\FWlib\Inc\Legacy;..\USRE;..\Utilities;..\BSP;..\APP;..\LwIP\include;..\LwIP\port;..\TcpClient;..\HAL;..\TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Objects\H7FreeRTOS.sct
  group USRE
    ../USRE/: main.c stm32h7xx_it.c header.h
  group APP
    ../APP/: App_core.c App_net.c
  group TcpApp
    ../TcpClient/: tcp_client.c tcp_server.c
  group BSP
    ../BSP/: Bsp_init.c Bsp_mpu.c Bsp_timer.c Bsp_gpio.c
  group Utilities
    ../Utilities/: RingBuff.c
  group lwip/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/netif
    ../LwIP/netif/: ethernet.c
  group lwip/port
    ../LwIP/port/: lwipopts.h netif_port.c sys_arch.c lan8742.c
  group freeRTOS
    ../freeRTOS/include/: FreeRTOSConfig.h
    ../freeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../freeRTOS/porttable/MemMang/: heap_4.c
    ../freeRTOS/porttable/RVDS/: port.c
  group CMSIS
    ../CMSIS/: system_stm32h7xx.c startup_stm32h743xx.s
  group FWlib
    ../FWlib/Inc/: stm32h7xx_hal_conf_template.h
    ../FWlib/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
